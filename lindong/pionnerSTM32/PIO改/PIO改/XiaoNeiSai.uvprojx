# Keil uVision project XiaoNeiSai.uvprojx, settings and files
target xiaoneisai (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XiaoNeiSai +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS;.\Libraries\inc;.\Drivers;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries
    ./Libraries/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_dac.c stm32f10x_flash.c
  group Drivers
    ./Drivers/: Delay.c Delay.h Encoder.h IOinput.c IOinput.h IOoutput.c IOoutput.h Encoder.c Motor.c Motor.h Sensor.c Sensor.h Servo.c Servo.h Usart.c Usart.h Pid.c Pid.h Tim.c mpu9250.c mpu9250.h
  group User
    ./User/: main.c main.h Config.h Global.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h schedule.c schedule.h systick.c systick.h datatrans.c datatrans.h
