# Keil uVision project Raccoons.uvprojx, settings and files
target Raccoons (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Raccoons +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,MPU9250,EMPL_TARGET_STM32F4,EMPL
  c include: ..\CMSIS;..\App;..\Drivers;..\Libraries\inc;..\User;..\Drivers\DMP\driver\eMPL;..\Drivers\DMP\driver\include;..\Drivers\DMP\driver\stm32L;..\Drivers\DMP\mllite;..\Drivers\DMP\eMPL-hal;..\Drivers\DMP\mpl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group Drivers
    ../Drivers/: Encoder.c Motor.c Pid.c function.c mpu9250.c mpuiic.c trifunction.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_flash.c
  group User
    ../Drivers/: Bsp.c
    ../User/: main.c Global.h Config.h stm32f10x_it.c
  group MPL
    ../Drivers/DMP/eMPL-hal/: eMPL_outputs.c
    ../Drivers/DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../Drivers/DMP/mpl/: libmpllib.lib
    ../Drivers/DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Drivers/DMP/driver/stm32L/: log_stm32.c
